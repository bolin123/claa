# IAR project claa.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: C:\工作目录\oldwang\software\claa\src\lib\inc; C:\工作目录\oldwang\software\claa\src\app
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: claa.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../../src/app/: APP.c DS18B20.c Hal.c S78S.c
    ./: main.c
  group lib
    ../../src/lib/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_usart.c
